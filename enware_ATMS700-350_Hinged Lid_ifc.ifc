Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2018-11-15T12:57:27
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Nov 15 12:57:27 2018 * Host: A2K_QLD_L056 * Database: C:\Users\danh\AppData\Local\Temp\{2A441F9F-97FD-4BF9-A76A-F3821A3ED3FC}\ifc * Database version: 5507 * Database creation date: Thu Nov 15 12:57:27 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Nov 15 12:57:27 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Nov 15 12:57:27 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: -35, -18, -23, -549194; RefLongitude: 149, 7, 35, 603027; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Ground Floor
LongName: Ground Floor; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Ground Floor; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Level Head - Triangle (AUS): Type 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowTerminal: Standard, TMV-Enware-ATMS700-350:Standard:391224
In: Ground Floor
Material: Metal-Brass-Enware-Nickel Plated, Plastic-Enware-Blue, Plastic-Enware-Red, Metal-Copper-Enware, Metal-Steel-Enware-Stainless Steel, Rubber-Enware-Black
Pset_ManufacturerTypeInformation - Manufacturer: Enware
Pset_DistributionFlowElementCommon - Reference: TMV-Enware-ATMS700-350:Standard
Constraints - Elevation: 0 mm; Host: Basic Wall : Double brick - 270; Level: Level: Ground Floor
Dimensions - Area: 0.5374 m2; Volume: 0.00179519 m3
Identity Data - Accessories: ATMSHL-350; Mark: 1
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - calcRecessVoid: 85 mm; Category: Plumbing Fixtures; Family: TMV-Enware-ATMS700-350: Standard; Family and Type: TMV-Enware-ATMS700-350: Standard; Schedule Level: Level: Ground Floor; Type: TMV-Enware-ATMS700-350: Standard; Type Id: TMV-Enware-ATMS700-350: Standard; validBoxPosition: 0 mm
Phasing - Phase Created: New Construction
Visibility - Hinged Lid: yes; Lid Selector: 1; Recessed Lid: no; Recess Mounted: yes; Surface Mounted: no
Constraints(Type) - Default Elevation: 1219.2 mm
Dimensions(Type) - Depth_ANZRS: 75 mm; Height_ANZRS: 350 mm; Pipe Extension Bottom: 100 mm; Pipe Radius: 11 mm; Width_ANZRS: 350 mm
Identity Data(Type) - CreatedBy_ANZRS: Design Content; CreatedByURL_ANZRS: https://www.designcontent.com.au/; Description: Aquablend 1500 Thermostatic Mixing Valve in 350 X 350 stainless steel cabinet; Manufacturer: Enware; Model: ATMS700-350; Type Name: Standard; URL: https://www.enware.com.au
Materials and Finishes(Type) - Fitting Material: Metal-Brass-Enware-Nickel Plated; Material: Metal-Steel-Enware-Stainless Steel; Pipework Material: Metal-Copper-Enware
Mechanical(Type) - CWFU: 0; HWFU: 0; MTWFU: 0
Other(Type) - Category: Plumbing Fixtures; calcOutsideHoleOffset: 75 mm; Family Name: TMV-Enware-ATMS700-350; HoleRadius: 12 mm
